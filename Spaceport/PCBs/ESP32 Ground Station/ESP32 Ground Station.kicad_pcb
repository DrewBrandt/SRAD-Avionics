# Repository DrewBrandt/SRAD-Avionics

## KiCad design Spaceport/PCBs/ESP32 Ground Station/ESP32 Ground Station.kicad_pcb

Parts:
BZ1: Buzzer; Buzzer_TDK_PS1240P02BT_D12.2mm_H6.5mm
C1, C3: 1u; C_0603_1608Metric
C2, C10, C11: 10u; C_0603_1608Metric
C4, C8: 100n; C_0603_1608Metric
C5, C6: DNP; C_0603_1608Metric
C7: 470n; C_0603_1608Metric
D1, D2: LED; LED_0805_2012Metric
D3: PWR3; LED_0805_2012Metric
D4, D5: D_Schottky; D_0603_1608Metric
D6: PWR; LED_0805_2012Metric
D7: PWR5; LED_0805_2012Metric
J1: Micro_SD_Card_Det1; microSD-GCT_MEM2085-00-115-00-A_REV0.2
J2: BAT; JST_PH_S2B-PH-K_1x02_P2.00mm_Horizontal
J3: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
J4: SMA; SMA_Amphenol_132289_EdgeMount
J5: Conn_02x10_Odd_Even; PinHeader_2x10_P2.54mm_Vertical
L2: 15u; L_1210_3225Metric
R1: 13k; R_0603_1608Metric
R2: 300; R_0603_1608Metric
R3, R4: 5k1; R_0603_1608Metric
R5, R6, R7, R8, R10, R11, R12, R15, R19: 10k; R_0603_1608Metric
R13, R16, R17, R18, R20, R22: 2k; R_0603_1608Metric
R14: 100k; R_0603_1608Metric
R21: 0; R_0603_1608Metric
SW1: SW_SPST; 50-0118-00
U1: ESP32-S3-MINI-1; ESP32-S2-MINI-1
U2: LBAA0XV2GT-001; LBAA0XV2GT001; Manufacturer_Part_Number LBAA0XV2GT-001
U3: XC6220B331MR; SOT-23-5
U4: USBLC6-2P6; SOT-666
U5: TPS22917DBV; SOT-23-6
U6: BQ25185DLHR; WSON10_DLH_TEX

Connections:
+3v3: C8.1, C11.2, J1.4 (VDD), J5.3, J5.4, R6.2, R7.2, R8.2, R10.2, R11.2, R12.2, R13.2, R15.1, U1.3 (3V3), U2.28 (VDD_1), U2.29 (VDD_2), U3.5 (VOUT)
+4v5-1: C2.2, D5.2 (A), U5.1 (VIN), U6.1 (SYS)
+4v5-2: C10.2, U3.1 (VIN), U3.3 (CE), U5.5 (QOD), U5.6 (VOUT)
/ANT: C5.1, R21.2, U2.19 (ANT_LORA_SUB_G_)
/ANT_1: C6.1, J4.1 (In), R21.1
/BAT_MEAS: R19.2, R20.2, U1.14 (IO10)
/BAT_STAT_1: U1.19 (IO15), U6.9 (STAT1)
/BAT_STAT_2: D1.2 (A), U6.3 (STAT2)
/BZ_IO: BZ1.1 (+), U1.28 (IO33)
/CC1: J3.A5 (CC1), R3.1
/CC2: J3.B5 (CC2), R4.1
/D+: U1.24 (USB_D+), U4.4 (I/O2)
/D+_1: J3.A6 (D+), J3.B6 (D+), U4.3 (I/O2)
/D-: U1.23 (USB_D-), U4.6 (I/O1)
/D-_1: J3.A7 (D-), J3.B7 (D-), U4.1 (I/O1)
/DCC: L2.1, U2.6 (DCC_SW)
/DGPIO: D6.2 (A), R18.1
/DPWR3: D3.2 (A), R13.1
/DPWR5: D7.2 (A), R22.1
/DSTAT1: D1.1 (K), R16.2
/DSTAT2: D2.2 (A), R17.1
/EN: J5.9, R15.2, U1.45 (EN)
/ILIM: R1.2, U6.7 (ILIM/VSET)
/IO0: J5.11, U1.4 (IO0)
/IO16: J5.17, U1.20 (IO16)
/IO47: J5.16, U1.27 (IO47)
/IO48: J5.18, U1.30 (IO48)
/ISET: R2.2, U6.8 (ISET)
/LED_BAT: R16.1, R17.2, U1.25 (IO21)
/LED_GPIO: R18.2, U1.29 (IO34)
/PWR_EN: C4.2, D4.1 (K), R14.2, SW1.1 (A), U5.3 (ON)
/RAD_BUSY: U1.33 (IO37), U2.9 (LR_BUSY)
/RAD_IO8: U1.31 (IO35), U2.2 (DIO8)
/RAD_IO9: U1.32 (IO36), U2.1 (DIO9)
/RAD_NRST: U1.34 (IO38), U2.35 (LR_NRST)
/RX: J5.7, U1.40 (RXD0)
/RX1: J5.15, U1.22 (IO18)
/SCL: J5.8, U1.13 (IO9)
/SDA: J5.6, U1.12 (IO8)
/SD_CD: J1.9 (DET), R12.1, U1.11 (IO7)
/SD_CLK: J1.5 (CLK), U1.5 (IO1)
/SD_CMD: J1.3 (CMD), R8.1, U1.6 (IO2)
/SD_DATA0: J1.7 (DAT0), R10.1, U1.7 (IO3)
/SD_DATA1: J1.8 (DAT1), R11.1, U1.8 (IO4)
/SD_DATA2: J1.1 (DAT2), R6.1, U1.9 (IO5)
/SD_DATA3: J1.2 (DAT3/CD), R7.1, U1.10 (IO6)
/SPI2_CS1: U1.18 (IO14), U2.10 (LR_NSS)
/SPI2_MISO: J5.10, U1.16 (IO12), U2.11 (LR_MISO)
/SPI2_MOSI: J5.12, U1.15 (IO11), U2.12 (LR_MOSI)
/SPI2_SCK: J5.14, U1.17 (IO13), U2.13 (LR_SCK)
/SW: D5.1 (K), SW1.2 (B)
/TSMR: R5.2, U6.6 (TS/MR)
/TX: J5.5, U1.39 (TXD0)
/TX1: J5.13, U1.21 (IO17)
/VREG: C7.2, L2.2, U2.4 (VREG)
GND: BZ1.2 (-), C1.1, C2.1, C3.1, C4.1, C5.2, C6.2, C7.1, C8.2, C10.1, C11.1, D2.1 (K), D3.1 (K), D6.1 (K), D7.1 (K), J1.6 (VSS), J1.10 (SHIELD), J2.2, J3.A1 (GND), J3.A12 (GND), J3.B1 (GND), J3.B12 (GND), J3.S1 (SHIELD), J4.2 (Ext), J5.1, J5.2, J5.19, J5.20, R1.1, R2.1, R3.2, R4.2, R5.1, R14.1, R20.1, U1.1 (GND), U1.2 (GND), U1.42 (GND), U1.43 (GND), U1.46 (GND), U1.47 (GND), U1.48 (GND), U1.49 (GND), U1.50 (GND), U1.51 (GND), U1.52 (GND), U1.53 (GND), U1.54 (GND), U1.55 (GND), U1.56 (GND), U1.57 (GND), U1.58 (GND), U1.59 (GND), U1.60 (GND), U1.61 (GND), U1.62 (GND), U1.63 (GND), U1.64 (GND), U1.65 (GND), U2.3 (GND_1), U2.5 (GND_2), U2.7 (GND_3), U2.8 (GND_4), U2.14 (GND_5), U2.16 (GND_6), U2.18 (GND_7), U2.20 (GND_8), U2.22 (GND_9), U2.26 (GND_10), U2.27 (GND_11), U2.30 (GND_12), U2.31 (GND_13), U2.32 (GND_14), U2.33 (GND_15), U2.34 (GND_16), U2.36 (GND_17), U2.37 (GND_18), U2.38 (GND_19), U2.39 (GND_20), U2.40 (GND_21)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
VBAT: C3.2, J2.1, R19.1, U6.2 (BAT)
VBUS: C1.2, D4.2 (A), J3.A4 (VBUS), J3.A9 (VBUS), J3.B4 (VBUS), J3.B9 (VBUS), R22.2, U4.5 (VBUS), U6.10 (IN)

Notes on the sheet:
Status Indicators
Battery Charger
Datasheet
SMA Antenna
MCU (ESP32-S3-MINI-1)
Radio (Murata Type G2T -- LR1121)
Power Switch
MicroSD Card
3.3v Linear Regulator
USB-C 2.0 Receptacle
GPIO Connectors
Datasheet - Switch
ESD Protection
Power and Batteries
Datasheet - LR1121

Board: 4 copper layers, 38.0 x 44.0 mm, 52 parts (32 on the bottom side), 58 nets.

## Commit log

2024-10-11 Revert "Create main.yml"
2025-03-26 Added Symbols and Symbol Library
2025-04-16 Push
2025-04-17 Push
    - Added pinout to GPS module
2025-04-17 Schematic Hierarchy
    - Added a page for reach sensor for better organization
2025-04-17 GPS Subcircuit
    - Note: VCC_IO, VCC_BCKP and VCC are tied based on integration manual
    - Integration manual https://github.com/xioTechnologies/SAM-M8Q-Breakout/blob/master/SAM-M8Q%20Datasheet.pdf
2025-04-29 Subcircuit Updates
2025-05-01 done first pass schematic
2025-05-01 early pcb layout
2025-05-01 changes to GS layout and Schem
2025-05-06 added data sheets to schematic
2025-05-06 Push after Schematic Review 5/5
    - Updated STM32 symbol
    - Configured I2C busses
    - Updated DC caps to 100nF
    - TODO add power system things
2025-05-06 initial STM32H7 project
2025-05-06 Working h7 build
2025-05-06 ESP32S3 builds
2025-05-07 First pass at building with MMFS
2025-05-07 add decoupling caps
2025-05-07 Layout mostly done for GS
2025-05-07 GS Traces complete
2025-05-07 aadded silk screen to GPIO pins
2025-05-09 Deployed ddb7b1d with MkDocs version: 1.6.1
2025-05-17 gerbers ig
